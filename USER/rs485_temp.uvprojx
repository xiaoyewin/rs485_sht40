# Keil uVision project rs485_temp.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SHT40 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c include: ..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Include;..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\USER;..\SYSTEM;..\HARDWARE;..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\lIb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c
    ../HARDWARE/: yd3082.c
  group lib
    ../lIb/: modbus_rtu.c
  group FWLIB
    ../FWLIB/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f030.s system_stm32f0xx.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group HARDWARE
    ../HARDWARE/: USART1.c USART1_API.c flash.c i2c_analog.c i2c_analog.h bmp280.c bmp280.h bh1750.c bh1750.h sht40.c sht40.h
